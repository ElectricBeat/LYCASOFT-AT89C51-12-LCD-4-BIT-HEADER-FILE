# Keil uVision project LDC_4_BIT_HEADER_FILE.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LDC_4_BIT_HEADER_FILE +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LCD_4_BIT_HEADER_FILE.c
